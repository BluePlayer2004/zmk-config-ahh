## boards/shields/painid/Kconfig.defconfig
```kconfig
if SHIELD_PAINID

config ZMK_KEYBOARD_NAME
    default "pain"

endif # SHIELD_PAINID
```
